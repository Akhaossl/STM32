# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Application/Driver
    ../Src/: delayus.c ShareWare.c tim8.c Loop.c uart.c tim4.c tim2.c tim3.c tim5.c adc1.c i2c.c
  group Application/Sensor
    ../Src/: IndicatorDevice.c Encoder.c BatteryInfor.c mpu6050.c RC.lib
  group Application/Control
    ../Src/: MotorControl.c VelocityControl.c pid.c DataCom.c DataProtocol.c RingBuff.lib LowPassFilter.lib Kinematics_Mecanum.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_i2c.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_can.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
software components: CMSIS:CORE 3.40.0
